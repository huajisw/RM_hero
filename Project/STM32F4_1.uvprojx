# Keil uVision project STM32F4_1.uvprojx, settings and files
target STM32F4 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4 +hex
  AfterMake: fromelf.exe --elf -o .\Objects\STM32F4.elf .\Objects\STM32F4.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: STM32F427X,USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,USE_STM324x9I_EVAL,USE_USB_OTG_FS,USE_ULPI_PHY
  c include: ..\Libraries\Include;..\Hardware\AHRS;..\Hardware\Main;..\Hardware\Initialize;..\Libraries\Include;..\Service\Application;..\System\DSP\Include;..\System\Freertos\include;..\Service\DJI_Judge;..\Libraries\include;..\System\Freertos\portable\RVDS\ARM_CM4F;..\System\CMSIS;..\Service\DJI_Judge;..\Hardware\Serial\USB_Driver\inc;..\Hardware\Serial\USB_Library\Core\inc;..\Hardware\Serial\USB_Library\Class\cdc\inc;..\Hardware\core
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Hardware/Main/: main.c
  group Startup
    ../Startup/: startup_stm32f427xx.s
  group Initialize
    ../Hardware/Initialize/: delay.c led.c usart.c can.c can.h usart.h usart1_dbus.c usart1_dbus.h PID.C oled.c oled_mode.c spi.c spi.h adc.c adc.h pwm.c pwm.h user_tool.c user_tool.h power.c power.h flash.c flash.h key.c key.h imu_bsp.c imu_bsp.h PC_usart.c exit.c PC_usart.h buzzer.c usb_usart.c usb_usart.h chassis_power_control.c
    ../Hardware/AHRS/: mpu6500_reg.h ist8310_reg.h
  group Libraries
    ../Libraries/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Freertos
    ../System/Freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../System/Freertos/portable/MemMang/: heap_4.c
    ../System/Freertos/portable/RVDS/ARM_CM4F/: port.c
  group AHRS
    ../Hardware/AHRS/: AHRS.lib AHRS.h AHRS_middleware.c ist8310driver.c ist8310driver_middleware.c mpu6500driver.c mpu6500driver_middleware.c
  group CMSIS
    ../System/CMSIS/: stm32f4xx_it.c system_stm32f4xx.c
  group DSP
    ../System/DSP/: arm_cortexM4lf_math.lib
  group Application
    ../Service/Application/: start_task.c FreeRTOS_middleware.c user_task.c oled_task.c oled_task.h judge_task.c judge_task.h IMU_task.c IMU_task.h shoot_task.c shoot_task.h DJI_Remote_Control.c DJI_Remote_Control.h oled_list.c oled_list.h gimbal_task.c chassis_task.c Check_Task.c Check_Task.h Mode_Set.c App_Set.h usb_task.c wit_c.sdk.h wit_c_sdk.c REG.h
    ./: chassis_power_control.h
  group help
    ../Service/Application/: usb_task.h
    ../User/: help.txt
  group DJI_Judge
    ../Service/DJI_Judge/: usart_judge.c usart_judge.h Judge_Data.c Judge_Data.h Judge_CRC.c Judge_CRC.h
  group Serial
    ../Hardware/Serial/USB_Driver/src/: usb_bsp.c usb_core.c usb_dcd.c usb_dcd_int.c
    ../Hardware/Serial/USB_Library/Core/src/: usbd_req.c usbd_usr.c usbd_cdc_vcp.c usbd_core.c usbd_desc.c usbd_ioreq.c
    ../Hardware/Serial/USB_Library/Class/cdc/src/: usbd_cdc_core.c usbd_cdc_if_template.c
